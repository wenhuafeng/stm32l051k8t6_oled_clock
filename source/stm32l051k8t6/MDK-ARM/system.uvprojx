# Keil uVision project system.uvprojx, settings and files
target system (6180000::V6.18::ARMCLANG)
  device: STM32L051K8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: system +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=.\$L@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32L051xx,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../../user/clock;../../user/common;../../user/oled;../../user/temp_humi;../../user/wifi;../../user/SEGGER_RTT_V782c/Config;../../user/SEGGER_RTT_V782c/RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c lptim.c rtc.c spi.c usart.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_pwr.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group user/clock
    ../../user/clock/: clock.c
  group user/common
    ../../user/common/: common.c fifo.c
  group user/oled
    ../../user/oled/: display.c fonts.c ssd1306_iic_hw.c ssd1306_iic_sw.c ssd1306.c
  group SEGGER_RTT_V782c
    ../../user/SEGGER_RTT_V782c/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group user/temp_humi
    ../../user/temp_humi/: si7021_iic_hw.c si7021_iic_sw.c si7021.c
  group user/wifi
    ../../user/wifi/: esp8266_at.c wifi_uart_if.c wifi_uart.c
software components: CMSIS:CORE 4.3.0
